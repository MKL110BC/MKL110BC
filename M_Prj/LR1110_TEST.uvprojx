# Keil uVision project LR1110_TEST.uvprojx, settings and files
target nrf52840_xxaa (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x00800000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: LR1110-TEST +hex
  AfterMake: .\hex2bin .\_build\LR1110-TEST.hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA NRF_SD_BLE_API_VERSION=7 S140 CONFIG_NFCT_PINS_AS_GPIOS REGION_EU_868 REGION_AS_923  REGION_US_915 REGION_AU_915 REGION_CN_470 REGION_IN_865 REGION_KR_920 REGION_RU_864 REGION_CN_470_RP_1_0 REGION_WW2G4 LR1110 LR1110_TRANSCEIVER ENABLE_MODEM_GNSS_FEATURE
  c misc: --reduce_paths
  c include: .\config;..\components;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fifo;..\components\libraries\fstorage;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\uart;..\components\libraries\util;..\components\nfc\ndef\conn_hand_parser;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\nfc\ndef\connection_handover\ac_rec;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\nfc\ndef\connection_handover\common;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\nfc\ndef\generic\message;..\components\nfc\ndef\generic\record;..\components\nfc\ndef\launchapp;..\components\nfc\ndef\parser\message;..\components\nfc\ndef\parser\record;..\components\nfc\ndef\text;..\components\nfc\ndef\uri;..\components\nfc\platform;..\components\nfc\t2t_lib;..\components\nfc\t2t_parser;..\components\nfc\t4t_lib;..\components\nfc\t4t_parser\apdu;..\components\nfc\t4t_parser\cc_file;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\nfc\t4t_parser\tlv;..\components\softdevice\common;..\components\softdevice\s140\headers;..\components\softdevice\s140\headers\nrf52;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;..\config;..\src;..\src\segger_rtt;..\components\ble\ble_services\ble_dis;..\components\ble\ble_advertising;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_api;..\src\lora_basic_modem_sdk\lora_basics_modem;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_hal;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\device_management;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lorawan_api;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src\lr1mac_class_c;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src\services;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src\smtc_real\src;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\lr1mac\src;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_config;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_core;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_services;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_services\fragmentation;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\modem_supervisor;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\radio_drivers\lr1110_driver\src;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\radio_planner\src;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_crypto;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\lr1110_secure_element;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_crypto\smtc_secure_element;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\headers;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\file_upload;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\src\stream;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_modem_services\src;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_ral\src;..\src\lora_basic_modem_sdk\lora_basics_modem\smtc_modem_core\smtc_ralf\src;..\src\lora_basic_modem_sdk\smtc_board;..\src\lora_basic_modem_sdk\smtc_hal\board;..\src\lora_basic_modem_sdk\smtc_hal\inc;..\src\lora_basic_modem_sdk\smtc_hal\LR1110\Helpers;..\src\lora_basic_modem_sdk\smtc_hal\LR1110\LR1110MB1LxKS\BSP\board;..\src\lora_basic_modem_sdk\smtc_hal\LR1110\LR1110MB1LxKS\BSP\ral_bsp;..\src\lora_basic_modem_sdk\smtc_hal\LR1110\radio_drivers_hal;..\src\soft_lib;..\src\sys;..\src\system_port;..\src\lora_basic_modem_sdk;..\src\lora_basic_modem_sdk\lbm_app;..\src\lora_basic_modem_sdk\smtc_hal\Nordic\nrf52840\inc
  asm define: APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED BOARD_PCA10100 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52833_XXAA NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT __HEAP_SIZE=71680 __STACK_SIZE=10240
  asm misc: --cpreproc_opts=-DAPP_TIMER_V2,-DAPP_TIMER_V2_RTC1_ENABLED,-DBOARD_PCA10100,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52833_XXAA,-DNRF_SD_BLE_API_VERSION=7,-DS140,-DSOFTDEVICE_PRESENT,-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\components;..\components\ble\ble_advertising;..\components\ble\ble_dtm;..\components\ble\ble_link_ctx_manager;..\components\ble\ble_racp;..\components\ble\ble_services\ble_ancs_c;..\components\ble\ble_services\ble_ans_c;..\components\ble\ble_services\ble_bas;..\components\ble\ble_services\ble_bas_c;..\components\ble\ble_services\ble_cscs;..\components\ble\ble_services\ble_cts_c;..\components\ble\ble_services\ble_dfu;..\components\ble\ble_services\ble_dis;..\components\ble\ble_services\ble_gls;..\components\ble\ble_services\ble_hids;..\components\ble\ble_services\ble_hrs;..\components\ble\ble_services\ble_hrs_c;..\components\ble\ble_services\ble_hts;..\components\ble\ble_services\ble_ias;..\components\ble\ble_services\ble_ias_c;..\components\ble\ble_services\ble_lbs;..\components\ble\ble_services\ble_lbs_c;..\components\ble\ble_services\ble_lls;..\components\ble\ble_services\ble_nus;..\components\ble\ble_services\ble_nus_c;..\components\ble\ble_services\ble_rscs;..\components\ble\ble_services\ble_rscs_c;..\components\ble\ble_services\ble_tps;..\components\ble\common;..\components\ble\nrf_ble_gatt;..\components\ble\nrf_ble_qwr;..\components\ble\peer_manager;..\components\boards;..\components\libraries\atomic;..\components\libraries\atomic_fifo;..\components\libraries\atomic_flags;..\components\libraries\balloc;..\components\libraries\bootloader\ble_dfu;..\components\libraries\bsp;..\components\libraries\button;..\components\libraries\cli;..\components\libraries\crc16;..\components\libraries\crc32;..\components\libraries\crypto;..\components\libraries\csense;..\components\libraries\csense_drv;..\components\libraries\delay;..\components\libraries\ecc;..\components\libraries\experimental_section_vars;..\components\libraries\experimental_task_manager;..\components\libraries\fds;..\components\libraries\fifo;..\components\libraries\fstorage;..\components\libraries\gfx;..\components\libraries\gpiote;..\components\libraries\hardfault;..\components\libraries\hci;..\components\libraries\led_softblink;..\components\libraries\log;..\components\libraries\log\src;..\components\libraries\low_power_pwm;..\components\libraries\mem_manager;..\components\libraries\memobj;..\components\libraries\mpu;..\components\libraries\mutex;..\components\libraries\pwm;..\components\libraries\pwr_mgmt;..\components\libraries\queue;..\components\libraries\ringbuf;..\components\libraries\scheduler;..\components\libraries\sdcard;..\components\libraries\slip;..\components\libraries\sortlist;..\components\libraries\spi_mngr;..\components\libraries\stack_guard;..\components\libraries\strerror;..\components\libraries\svc;..\components\libraries\timer;..\components\libraries\twi_mngr;..\components\libraries\twi_sensor;..\components\libraries\uart;..\components\libraries\usbd;..\components\libraries\usbd\class\audio;..\components\libraries\usbd\class\cdc;..\components\libraries\usbd\class\cdc\acm;..\components\libraries\usbd\class\hid;..\components\libraries\usbd\class\hid\generic;..\components\libraries\usbd\class\hid\kbd;..\components\libraries\usbd\class\hid\mouse;..\components\libraries\usbd\class\msc;..\components\libraries\util;..\components\nfc\ndef\conn_hand_parser;..\components\nfc\ndef\conn_hand_parser\ac_rec_parser;..\components\nfc\ndef\conn_hand_parser\ble_oob_advdata_parser;..\components\nfc\ndef\conn_hand_parser\le_oob_rec_parser;..\components\nfc\ndef\connection_handover\ac_rec;..\components\nfc\ndef\connection_handover\ble_oob_advdata;..\components\nfc\ndef\connection_handover\ble_pair_lib;..\components\nfc\ndef\connection_handover\ble_pair_msg;..\components\nfc\ndef\connection_handover\common;..\components\nfc\ndef\connection_handover\ep_oob_rec;..\components\nfc\ndef\connection_handover\hs_rec;..\components\nfc\ndef\connection_handover\le_oob_rec;..\components\nfc\ndef\generic\message;..\components\nfc\ndef\generic\record;..\components\nfc\ndef\launchapp;..\components\nfc\ndef\parser\message;..\components\nfc\ndef\parser\record;..\components\nfc\ndef\text;..\components\nfc\ndef\uri;..\components\nfc\platform;..\components\nfc\t2t_lib;..\components\nfc\t2t_parser;..\components\nfc\t4t_lib;..\components\nfc\t4t_parser\apdu;..\components\nfc\t4t_parser\cc_file;..\components\nfc\t4t_parser\hl_detection_procedure;..\components\nfc\t4t_parser\tlv;..\components\softdevice\common;..\components\softdevice\s140\headers;..\components\softdevice\s140\headers\nrf52;..\external\fprintf;..\external\segger_rtt;..\external\utf_converter;..\integration\nrfx;..\integration\nrfx\legacy;..\modules\nrfx;..\modules\nrfx\drivers\include;..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x800000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ./: main.c
    ./config/: sdk_config.h
  group nRF_Drivers
    ../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c nrf_drv_twi.c nrf_drv_rng.c
    ../modules/nrfx/soc/: nrfx_atomic.c
    ../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_spim.c nrfx_saadc.c nrfx_twim.c nrfx_wdt.c nrfx_rng.c
    ../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../modules/nrfx/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../components/libraries/hardfault/: hardfault_implementation.c
    ../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../components/libraries/atomic_flags/: nrf_atflags.c
    ../components/libraries/atomic/: nrf_atomic.c
    ../components/libraries/balloc/: nrf_balloc.c
    ../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../components/libraries/memobj/: nrf_memobj.c
    ../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../components/libraries/ringbuf/: nrf_ringbuf.c
    ../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../components/libraries/sortlist/: nrf_sortlist.c
    ../components/libraries/strerror/: nrf_strerror.c
    ../components/libraries/uart/: retarget.c
    ../components/libraries/timer/: app_timer.c
    ../components/libraries/queue/: nrf_queue.c
  group RTT
    ../src/segger_rtt/: SEGGER_RTT_printf.c SEGGER_RTT.c
  group soft_lib
    ../src/soft_lib/: system_time.c
  group lbm_dm
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/device_management/: dm_downlink.c modem_context.c
  group lbm_lorawan_api
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lorawan_api/: lorawan_api.c
  group lbm_lr1mac
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/lr1mac_class_c/: lr1mac_class_c.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/services/: smtc_duty_cycle.c smtc_lbt.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/smtc_real/src/: region_as_923.c region_au_915.c region_cn_470.c region_cn_470_rp_1_0.c region_eu_868.c region_in_865.c region_kr_920.c region_ru_864.c region_us_915.c region_ww2g4.c smtc_real.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/lr1mac/src/: lr1_stack_mac_layer.c lr1mac_core.c lr1mac_utilities.c
  group lbm_modem_core
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/modem_core/: smtc_modem.c smtc_modem_api_lr1110_crypto_engine.c smtc_modem_api_lr1110_system.c smtc_modem_test.c
  group lbm_modem_service
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/modem_services/: fifo_ctrl.c lorawan_certification.c modem_utilities.c smtc_clock_sync.c smtc_modem_services_hal.c
  group lbm_modem_sup
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/modem_supervisor/: modem_supervisor.c
  group lbm_radio_driver
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/radio_drivers/lr1110_driver/src/: lr1110_bootloader.c lr1110_crypto_engine.c lr1110_driver_version.c lr1110_gnss.c lr1110_radio.c lr1110_radio_timings.c lr1110_regmem.c lr1110_system.c lr1110_wifi.c
  group lbm_radio_planner
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/radio_planner/src/: radio_planner.c radio_planner_hal.c
  group lbm_smtc_modem_crypto
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/lr1110_secure_element/: lr1110_se.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_crypto/: smtc_modem_crypto.c
  group lbm_smtc_ral
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_ral/src/: ral_lr1110.c
  group lbm_smtc_ralf
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_ralf/src/: ralf_lr1110.c
  group lbm_smtc_modem_service
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/alc_sync/: alc_sync.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/almanac_update/: almanac_update.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/file_upload/: file_upload.c
    ../src/lora_basic_modem_sdk/lora_basics_modem/smtc_modem_core/smtc_modem_services/src/stream/: rose.c stream.c
  group lbm_smtc_hal_port
    ../src/lora_basic_modem_sdk/smtc_hal/LR1110/Helpers/: lr1110_geolocation_helpers.c
    ../src/lora_basic_modem_sdk/smtc_hal/LR1110/LR1110MB1LxKS/BSP/board/: lr1110_mb1lxks_board.c
    ../src/lora_basic_modem_sdk/smtc_hal/LR1110/LR1110MB1LxKS/BSP/ral_bsp/: ral_lr1110_bsp.c
    ../src/lora_basic_modem_sdk/smtc_hal/LR1110/radio_drivers_hal/: lr1110_hal.c
    ../src/lora_basic_modem_sdk/smtc_hal/Nordic/nrf52840/smtc_modem_hal/: smtc_modem_hal.c
    ../src/lora_basic_modem_sdk/smtc_hal/Nordic/nrf52840/src/: smtc_hal_adc.c smtc_hal_flash.c smtc_hal_gpio.c smtc_hal_i2c.c smtc_hal_lp_timer.c smtc_hal_mcu.c smtc_hal_rng.c smtc_hal_rtc.c smtc_hal_spi.c smtc_hal_trace.c smtc_hal_watchdog.c
  group lbm_app
    ../src/lora_basic_modem_sdk/lbm_app/: apps_modem_common.c apps_modem_event.c apps_utilities.c lbm_app.c wifi_helpers.c gnss_helpers.c
  group sys
    ../src/sys/: platform_driver.c wdt.c in_flash_manage.c
target flash_s140_nrf52_7.0.1_softdevice (ARM-ADS)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.32.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: s140_nrf52_7.0.1_softdevice.hex +hex
  BeforeMake: attrib +R $H\*
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  c misc: --reduce_paths
  c include: ..\..\..\config;..\config
  asm define: __HEAP_SIZE=2048 __STACK_SIZE=2048
  asm misc: --cpreproc_opts=-D__HEAP_SIZE=2048,-D__STACK_SIZE=2048
  asm include: ..\..\..\config;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0x59000
  memory RVCT9: RAM 0x20002ae8 size 0x1d518
  link misc: --diag_suppress 6330
software components: CMSIS:CORE 5.3.0, Device:Startup 8.32.1
